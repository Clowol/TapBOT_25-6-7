# Keil uVision project EndEffector_SubBoard.uvprojx, settings and files
target EndEffector_SubBoard (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: EndEffector_SubBoard +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS\Device;..\Drivers\CMSIS\Core;..\FWlib\inc;..\App;..\App\CPU;..\BSP;..\Comm;..\Protocols;..\Actuators
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Core/: core_cm3.c
    ../Drivers/CMSIS/Device/: system_stm32f10x.c startup_stm32f10x_md.s
  group FWlib
    ../FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group App
    ../App/: main.c end_effector_task.c app_config.h stm32f10x_conf.h
    ../App/CPU/: stm32f10x_it.c
  group BSP
    ../BSP/: delay.c gpio.c usart.c
  group Comm
    ../Comm/: ring_buf.c rs485_link.c
  group Protocols
    ../Protocols/: subboard_protocol.c
  group Actuators
    ../Actuators/: feetech_servo.c pushrod.c
