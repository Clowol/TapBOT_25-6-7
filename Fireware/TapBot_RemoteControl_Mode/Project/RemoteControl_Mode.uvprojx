# Keil uVision project RemoteControl_Mode.uvprojx, settings and files
target RemoteControl_Mode (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RemoteControl_Mode +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\Drivers\CMSIS\Device;..\Drivers\CMSIS\Core;..\FWlib\inc;..\FWlib\src;..\Trdlib;..\Trdlib\GO-M8010-6;..\Trdlib\wit_c_sdk;..\Actuators;..\App;..\App\CPU;..\BSP;..\Comm;..\Control;..\Protocols
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Drivers/CMSIS
    ../Drivers/CMSIS/Core/: core_cm3.c core_cm3.h
    ../Drivers/CMSIS/Device/: system_stm32f10x.c
  group Drivers
    ../Drivers/CMSIS/Device/: startup_stm32f10x_cl.s
  group FWlib
    ../FWlib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
    ../FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ../App/: main.c function.c
  group BSP
    ../BSP/: sys.c delay.c led.c timer.c adc.c switch.c encoder.c wit_imu.c
  group Comm
    ../Comm/: usart.c ring_buf.c uart_rx_driver.c can1.c can2.c subboard_link.c
  group Control
    ../Control/: control_math.c control_dispatcher.c
  group Protocols
    ../Protocols/: ros2_comm.c rmt_comm.c upper_comm.c upper_feedback.c up_data.c rmt_data.c subboard_protocol.c
  group Actuators
    ../Actuators/: steer_data.c ptz_data.c yushu_motor_data.c
  group Trdlib
    ../Trdlib/GO-M8010-6/: crc_ccitt.h GO-M8010-6.c motor_control.h ris_protocol.h
    ../Trdlib/wit_c_sdk/: wit_c_sdk.c wit_c_sdk.h REG.h
